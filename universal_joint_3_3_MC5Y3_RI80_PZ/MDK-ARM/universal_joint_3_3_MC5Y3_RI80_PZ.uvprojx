# Keil uVision project universal_joint_3_3_MC5Y3_RI80_PZ.uvprojx, settings and files
target universal_joint_3_3_MC5Y3_RI80_PZ (6160000::V6.16::ARMCLANG)
  device: STM32G431VBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: universal_joint_3_3_MC5Y3_RI80_PZ
  AfterMake: "./UserCommandRunAfterCompile.bat"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: ARM_MATH_CM4,USE_HAL_DRIVER,STM32G431xx,ENCODER_PZ2656
  c include: ../Inc;                         ../Drivers/STM32G4xx_HAL_Driver/Inc;                         ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;                         ../MCSDK_v5.Y.3/MotorControl/MCSDK/MCLib/G4xx/Inc;                         ../MCSDK_v5.Y.3/MotorControl/MCSDK/MCLib/Any/Inc;                         ../Drivers/CMSIS/Device/ST/STM32G4xx/Include;                         ../Drivers/CMSIS/Include;                         ../Drivers/CMSIS/DSP/Include;                       ../../commons
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Src/: main.c motorcontrol.c mc_api.c mc_config.c mcp_config.c mc_tasks.c pwm_curr_fdbk.c regular_conversion_manager.c mc_math.c mc_interface.c stm32g4xx_mc_it.c mc_parameters.c register_interface.c usart_aspep_driver.c mc_configuration_registers.c aspep.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_comp.c stm32g4xx_hal_cordic.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Middlewares/MotorControl
    ../MCSDK_v5.Y.3/MotorControl/lib/: libmc-keil_M4.lib
    ../MCSDK_v5.Y.3/MotorControl/MCSDK/MCLib/G4xx/Src/: stspin32g4.c r3_2_g4xx_pwm_curr_fdbk.c
    ../MCSDK_v5.Y.3/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c enc_align_ctrl.c encoder_speed_pos_fdbk.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_common.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c virtual_speed_sensor.c mcp.c mcpa.c
  group Commons
    ../../commons/: fsm.c pz_1sf_driver.c universal_joint.c
